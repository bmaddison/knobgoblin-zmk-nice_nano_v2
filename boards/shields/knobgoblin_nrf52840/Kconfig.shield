## boards/shields/knobgoblin_nrf52840/Kconfig.shield
```kconfig
config SHIELD_KNOBGOBLIN_NRF52840
    def_bool $(shields_list_contains,knobgoblin_nrf52840)
```
